# Keil uVision project BLACK1.uvprojx, settings and files
target BLACK1 (6070000::V6.7::.\ARMCLANG)
  device: STM32H753IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF)             CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: BLACK1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H753xx
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../MDK-ARM;./HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h753xx.s
  group Application/User
    ./: U8_Float.c U8_Float.h
    ../Src/: main.c gpio.c dma.c memorymap.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group HARDWARE
    ./HARDWARE/: UWB.c UWB.h Xsense.c Depth_Sensor.c Depth_Sensor.h GuangXian.c GuangXian.h Dvl.c Cal_V_Angular.c Navigation.c
    ./: Xsense.h
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
software components: CMSIS:CORE 5.6.0
